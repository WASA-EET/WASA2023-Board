# Repository WASA-EET/WASA2023-Board

File README.md:

# WASA2023-Board
操舵・計測基板

KiCADで製作

## KiCad design WASA2023.kicad_pcb

Parts:
BZ1: Buzzer; Buzzer_12x9.5RM7.6
D1: LED; LED_D5.0mm_Clear
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J2, J4, J8: Conn_01x05; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J3, J9, J11: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J5: Conn_01x02; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J6: Conn_01x06; PinSocket_1x06_P2.54mm_Vertical
J7, J10: Conn_01x03; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J12, J13: Conn_01x04; PinSocket_1x04_P2.54mm_Vertical
J14: Conn_01x10; PinSocket_1x10_P2.54mm_Vertical
J15, J16: Conn_01x02; PinSocket_1x02_P2.54mm_Vertical
R1, R2, R3, R4: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1, SW2, SW3, SW4: SW_Push; SW_PUSH_6mm
SW5: SW_Push_SPDT; PinSocket_1x03_P2.54mm_Vertical
U1, U2: ESP32-DevKitC

Connections:
+3.3V: J1.2, J2.2, J4.2, J6.1, J7.2, J8.5, J10.3, J12.4, J14.7, R2.2, R3.2, R4.2, U1.1 (3V3), U2.1 (3V3)
+5V: J9.1, J11.4, U1.19 (5V), U2.19 (5V)
/4A: R1.1, U1.26 (ADC2_CH0/GPIO4)
/4B: J10.2, U2.26 (ADC2_CH0/GPIO4)
/5A: J4.4, U1.29 (GPIO5)
/5B: J14.9, U2.29 (GPIO5)
/12A: J2.5, U1.13 (MTDI/GPIO12/ADC2_CH5)
/12B: J6.4, U2.13 (MTDI/GPIO12/ADC2_CH5)
/13A: J1.5, U1.15 (MTCK/GPIO13/ADC2_CH4)
/13B: J6.2, U2.15 (MTCK/GPIO13/ADC2_CH4)
/14A: SW3.1, U1.12 (MTMS/GPIO14/ADC2_CH6)
/14B: J6.5, U2.12 (MTMS/GPIO14/ADC2_CH6)
/15A: SW4.1, U1.23 (MTDO/GPIO15/ADC2_CH3)
/15B: J6.6, U2.23 (MTDO/GPIO15/ADC2_CH3)
/18A: J4.3, U1.30 (GPIO18)
/18B: J14.6, U2.30 (GPIO18)
/19A: SW5.2 (B), U1.31 (GPIO19)
/19B: J14.4, U2.31 (GPIO19)
/21A: SW1.1, U1.33 (GPIO21)
/21B: J12.2, R3.1, U2.33 (GPIO21)
/22A: SW2.1, U1.36 (GPIO22)
/22B: J12.1, R2.1, U2.36 (GPIO22)
/23A: J4.5, U1.37 (GPIO23)
/23B: J14.8, U2.37 (GPIO23)
/25A: J3.2, U1.9 (DAC_1/ADC2_CH8/GPIO25)
/25B: BZ1.1 (-), U2.9 (DAC_1/ADC2_CH8/GPIO25)
/26A: J3.3, U1.10 (DAC_2/ADC2_CH9/GPIO26)
/26B: J8.3, U2.10 (DAC_2/ADC2_CH9/GPIO26)
/27A: J3.4, U1.11 (ADC2_CH7/GPIO27)
/27B: J8.2, U2.11 (ADC2_CH7/GPIO27)
/32A: J1.4, U1.7 (32K_XP/GPIO32/ADC1_CH4)
/32B: J9.3, U2.7 (32K_XP/GPIO32/ADC1_CH4)
/33A: J1.3, U1.8 (32K_XN/GPIO33/ADC1_CH5)
/33B: J9.4, U2.8 (32K_XN/GPIO33/ADC1_CH5)
/34A: J2.4, U1.5 (VDET_1/GPIO34/ADC1_CH6)
/34B: J7.1, U2.5 (VDET_1/GPIO34/ADC1_CH6)
/35A: J2.3, U1.6 (VDET_2/GPIO35/ADC1_CH7)
/35B: J8.4, U2.6 (VDET_2/GPIO35/ADC1_CH7)
/RX2B: J11.1, U2.27 (GPIO16)
/TX2A: J5.1, U1.28 (GPIO17)
/TX2B: J11.2, U2.28 (GPIO17)
GND: BZ1.2 (+), D1.1 (K), J1.1, J2.1, J3.1, J4.1, J5.2, J6.3, J7.3, J8.1, J9.2, J10.1, J11.3, J12.3, J14.5, SW1.2, SW2.2, SW3.2, SW4.2, SW5.3 (C), U1.14 (GND), U1.32 (GND), U1.38 (GND), U2.14 (GND), U2.32 (GND), U2.38 (GND)
unnamed: D1.2 (A), R1.2
unnamed: R4.1, SW5.1 (A)

Notes on the sheet:
基準角調整
電源フラグ
無線操舵有効 or 無効
操舵系統
計測系統
マウント穴（M3）
トリム
操縦桿・サーボ
GPS
高度計
ラダー
※ 3.3Vと3V3を併用しないこと！ （別の電圧源と解釈されるので滅茶苦茶になる）
エレベーター
スライドスイッチ
プルアップしておくこと
気圧・温度計
速度計
トリム表示
SDカード
9軸センサ
サーボ
回転数計
トリム操作
ただのエラー防止。技術的な意味はない

Board: 2 copper layers, 95.2 x 95.2 mm, 33 parts (0 on the bottom side), 44 nets.

File production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
BZ1,Buzzer_12x9.5RM7.6,1,Buzzer,
D1,LED_D5.0mm_Clear,1,LED,
"H1, H2, H3, H4",MountingHole_3.2mm_M3,4,MountingHole,
"J1, J2, J4, J8",JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical,4,Conn_01x05,
"J10, J7",JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical,2,Conn_01x03,
"J11, J3, J9",JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,3,Conn_01x04,
"J12, J13",PinSocket_1x04_P2.54mm_Vertical,2,Conn_01x04,
J14,PinSocket_1x10_P2.54mm_Vertical,1,Conn_01x10,
"J15, J16",PinSocket_1x02_P2.54mm_Vertical,2,Conn_01x02,
J5,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,Conn_01x02,
J6,PinSocket_1x06_P2.54mm_Vertical,1,Conn_01x06,
"R1, R2, R3, R4",R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal,4,10k,
"SW1, SW2, SW3, SW4",SW_PUSH_6mm,4,SW_Push,
SW5,PinSocket_1x03_P2.54mm_Vertical,1,SW_Push_SPDT,
"U1, U2",ESP32-DevKitC,2,ESP32-DevKitC,
